# Keil uVision project atk_f103.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_USB_FS
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\User\APP;..\..\Middlewares;..\..\Middlewares\GUI;..\..\Middlewares\NES;..\..\Middlewares\SMS;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\USB\USB_HAL;..\..\Middlewares\UCOSII\uC-CPU\Cfg\Template;..\..\Middlewares\UCOSII\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-CPU;..\..\Middlewares\UCOSII\uC-LIB\Cfg\Template;..\..\Middlewares\UCOSII\uC-LIB;..\..\Middlewares\UCOSII\uC-OS2\Cfg\Template;..\..\Middlewares\UCOSII\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-OS2\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c
  group User/APP
    ../../User/APP/: spb.c common.c calendar.c ebook.c picviewer.c lyric.c audioplay.c settings.c tomcatplay.c recorder.c nesplay.c notepad.c exeplay.c paint.c camera.c usbplay.c wirelessplay.c calculator.c phoneplay.c vmeterplay.c appplay.c appplay_remote.c beepplay.c ledplay.c keyplay.c netplay.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/EXTI/: exti.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/SDIO/: sdio_sdcard.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/VS10XX/: vs10xx.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/SPBLCD/: spblcd.c
    ../../Drivers/BSP/DS18B20/: ds18b20.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/TPAD/: tpad.c
    ../../Drivers/BSP/ADC/: adc.c adc3.c
    ../../Drivers/BSP/LSENS/: lsens.c
    ../../Drivers/BSP/DMA/: dma.c
    ../../Drivers/BSP/JOYPAD/: joypad.c
    ../../Drivers/BSP/USART3/: usart3.c
    ../../Drivers/BSP/OV7725/: ov7725.c sccb.c
    ../../Drivers/BSP/NRF24L01/: nrf24l01.c
    ../../Drivers/BSP/GSM/: gsm.c
    ../../Drivers/BSP/REMOTE/: remote.c
    ../../Drivers/BSP/CH395Q/: ch395q.c ch395q_cmd.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/UCOSII/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/UCOSII/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/UCOSII/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/UCOSII/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/GUI
    ../../Middlewares/GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group Middlewares/AUDIOCODEC
    ../../Middlewares/AUDIOCODEC/: mp3player.c
  group Middlewares/NES
    ../../Middlewares/NES/: nes_apu.c nes_crc32.c nes_main.c nes_mapper.c nes_ppu.c 6502.s
  group Middlewares/T9INPUT
    ../../Middlewares/T9INPUT/: pyinput.c t9input.c
  group Middlewares/ATKNCR
    ../../Middlewares/ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
  group Middlewares/USB_HAL
    ../../Middlewares/USB/USB_HAL/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Readme
    ../../: readme.txt
